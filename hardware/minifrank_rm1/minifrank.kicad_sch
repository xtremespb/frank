File: hardware/minifrank_rm1/minifrank.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: RM1 HW 2.01
Other:
- title: MiniFRANK -> MiniFRANK RM1
