File: hardware/minifrank_rm1/audio.kicad_sch (KiCad schematic)
At the start: 15 parts

Commit message: RM1 HW 2.01
Other:
- title: MiniFRANK -> MiniFRANK RM1
