File: hardware/minifrank_rm1/power.kicad_sch (KiCad schematic)
At the start: 8 parts, among them U1 NCP1117 3.3

Commit message: RM1 HW 2.01
Other:
- title: MiniFRANK -> MiniFRANK RM1
